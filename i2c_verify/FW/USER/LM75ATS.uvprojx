# Keil uVision project LM75ATS.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LM75ATS +hex
  AfterMake: fromelf --bin -o ".\bin\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWlib\inc;..\FWlib\src;..\CMSIS\CM3\CoreSupport;.\ADC_DMA;.\TIMER;.\rtt;.\delay;.\sys
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTCODE
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group USER
    ./: main.c stm32f10x_it.c
    ./ADC_DMA/: ADC_DMA.c
    ./rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Conf.c
    ./delay/: delay.c
    ./sys/: sys.c
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_i2c.c
  group CMSIS
    ../CMSIS/CM3/: system_stm32f10x.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
